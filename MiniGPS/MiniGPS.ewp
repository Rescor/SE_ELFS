# IAR project MiniGPS.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: LANG_RU; OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release_RU (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LANG_RU; OLDFUNCTIONS
configuration Release_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LANG_EN; OLDFUNCTIONS
configuration Release_CN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LANG_CN; OLDFUNCTIONS
  group (top)
    ../C++/: _cpp2.cpp
    ./: conf_loader.cpp conf_loader.h config_data.c config_data.h LANG_CN.h LANG_EN.h LANG_RU.h language.h main.c main.h menu.c menu.h nums.h util.h utils.c
    ../include/: func.asm
