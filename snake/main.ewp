# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.PreInclude: ..\deleaker\mem2.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: CGame.c CGameDisp.c CMyBook.c display.c food.c main.c map.c rand.c rand.h snake.c
    ../classlib/: cl.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp
