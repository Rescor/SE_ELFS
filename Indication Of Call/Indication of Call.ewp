# IAR project Indication of Call.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration Release_en (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ENG
  group (top)
    ../C++/: _cpp2.cpp
    ./: conf_loader.cpp config_data.c Indication of Call.c
    ../include/: func.asm
