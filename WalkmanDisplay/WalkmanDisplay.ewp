# IAR project WalkmanDisplay.ewp, settings and files
configuration Debug (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: RUS; OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: 1.xcl
configuration Release_ENG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ENG; OLDFUNCTIONS
configuration Release_RU (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; RUS; OLDFUNCTIONS
  group (top)
    ./: accelctrl.cpp cfg_2_0.h cfg_2_0_corrupted.h cfg_2_1.h cl.cpp conf_loader.cpp config_data.c CurrentTrack.cpp decoder2.cpp DecoderInit.cpp encoding.cpp images.cpp main.cpp migrate_2_0.cpp migrate_2_0_corrupted.cpp skin_data.cpp skin_loader.cpp tag.cpp tag_reset.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h
