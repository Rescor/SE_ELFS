# IAR project EventControl.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS
  XLINK.XclFile: 1.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: act_proc.cpp book.c calc.cpp Events.c gui.cpp lng.cpp main.cpp messagebox.cpp process.cpp rem_imp.cpp remind.cpp sort.cpp string.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h
