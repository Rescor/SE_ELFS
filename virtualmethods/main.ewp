# IAR project main.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../classlib/: cl.cpp cl.h
    ./: CUnit.hpp CUnitRect.cpp CUnitRect.hpp CUnitRound.cpp CUnitRound.hpp CUnits.cpp CUnits.hpp CUnitSine.cpp CUnitSine.hpp CUnitStars.cpp CUnitStars.hpp main.cpp mybook.cpp mybook.h mydisp.cpp mydisp.h rand.c rand.h sin.c sin.h
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h
