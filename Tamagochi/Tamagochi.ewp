# IAR project Tamagochi.ewp, settings and files
configuration Release_RU (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; LANG_RU; OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LANG_EN; OLDFUNCTIONS
configuration Debug_RU (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LANG_RU; OLDFUNCTIONS
configuration Debug_EN (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LANG_EN; OLDFUNCTIONS
configuration Release_CN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LANG_CN; OLDFUNCTIONS
configuration Release_CZ (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LANG_CZ; OLDFUNCTIONS
configuration Release_PL (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LANG_PL; OLDFUNCTIONS
configuration Release_SP (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LANG_SP; OLDFUNCTIONS
configuration Release_PTB (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; LANG_PTB; OLDFUNCTIONS
  group (top)
    ../C++/: _cpp2.cpp
    ./: conf_loader.cpp conf_loader.h config_data.c crypt.c crypt.h gui.c LANG_CN.h LANG_CZ.h LANG_EN.h LANG_PL.h LANG_PTB.h LANG_RU.h LANG_SP.h language.h main.c misc_util.h RANDOM.H splitutils.c status.c strncmpi.c Tamagochi.h
    ../include/: func.asm
