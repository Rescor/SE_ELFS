# IAR project Scalka.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NO_AP_ASSERT; NDEBUG; OLDFUNCTIONS
  XLINK.XclFile: ..\include\1.xcl
  group (top)
    ../C++/: _cpp2.cpp
    ./: calc_menu.cpp calc_object.c gammaf.cpp main.c
    ../include/: func.asm
