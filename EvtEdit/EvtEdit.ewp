# IAR project EvtEdit.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS
  XLINK.XclFile: ..\include\1.xcl
  group (top)
    ./: addevt.c date.c days.c Events.c indication.cpp JavaList.c lng.cpp main.cpp profile.c SelectFile.c shortcut.c string.cpp StringInput.c switchmenu.cpp time.c vol_inp.cpp
    ../include/: func.asm
    ../deleaker/: mem2.cpp mem2.h
