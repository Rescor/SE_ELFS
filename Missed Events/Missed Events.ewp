# IAR project Missed Events.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: OLDFUNCTIONS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\include\1.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; OLDFUNCTIONS
configuration Release_en (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default        None
  ICCARM.CCDefines: NDEBUG; ENG; OLDFUNCTIONS
  group (top)
    ../C++/: _cpp2.cpp
    ./: conf_loader.cpp config_data.c Missed Events.c string.cpp
    ../include/: func.asm
